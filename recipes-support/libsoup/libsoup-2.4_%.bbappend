BBCLASSEXTEND = "native"
DEPENDS += "glib-networking"
